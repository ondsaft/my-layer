ROOTFS_POSTPROCESS_COMMAND_remove = "empty_var_volatile;"
